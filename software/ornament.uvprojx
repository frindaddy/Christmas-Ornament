# Keil uVision project ornament.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) IROM2(0x1FFF0080,0x00000010) XROM(0x1FFF0280,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ornament
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32F002Bx5,USE_FULL_LL_DRIVER
  c include: .\PY32F0xx_Drivers\Inc
  memory RVCT1: ROM 0x1fff0280 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT5: ROM 0x1fff0080 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Source Group 1
    ./: main.c
    ./PY32F0xx_Drivers/Src/: py32f0xx_ll_exti.c py32f0xx_ll_gpio.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
